## Config.in
```kconfig
config BR2_PACKAGE_GOGPIO
    bool "gogpio"
    depends on BR2_PACKAGE_HOST_GO_TARGET_ARCH_SUPPORTS 
    help
        a simple Go application with GPIO support
```
